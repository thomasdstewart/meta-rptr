inherit pypi setuptools3
