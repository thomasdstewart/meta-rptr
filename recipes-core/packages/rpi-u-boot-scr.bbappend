FILESEXTRAPATHS:prepend := "${THISDIR}/rpi-u-boot-scr:"

